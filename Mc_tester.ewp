# IAR project Mc_tester.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2410 MSP430F2410
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: src\testi; src\scheduler; src\graphics; src\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2410.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    src/: ini.c ini.h main.c main.h run.c run.h str_funkcije.c str_funkcije.h
  group graphics
    src/graphics/: graphics.c graphics.h graphics_LCD2.c graphics_LCD2.h
  group scheduler
    src/scheduler/: scheduler.c scheduler.h TIMERB.C TIMERB.H
  group Testi
    src/testi/: backlight_test.c backlight_test.h error_mng.c error_mng.h flash_test.c flash_test.h ledice_test.c ledice_test.h pini_test.c pini_test.h test_mng.c test_mng.h tipke_test.c tipke_test.h
